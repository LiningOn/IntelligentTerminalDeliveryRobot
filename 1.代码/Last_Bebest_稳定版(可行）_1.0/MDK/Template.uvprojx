# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,ARM_MATH_CM4,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c misc: --diag_suppress=767,188,177
  c include: ..\MDK;..\CONFIG\CORE;..\CONFIG\FreeRTOS;..\CONFIG\FreeRTOS\include;..\CONFIG\FreeRTOS\portable\RVDS\ARM_CM4F;..\CONFIG\FWLIB\inc;..\CONFIG\SYSTEM\delay;..\CONFIG\SYSTEM\sys;..\CONFIG\SYSTEM\usart;..\CONFIG\HardWare\USART;..\SRC\PID;..\SRC\FSM;..\SRC\SPEED_ANALYSIS;..\SRC\DEBUG;..\SRC\PERPHERAL;..\CONFIG\BSP;..\CONFIG\IIC;..\CONFIG\MPU6050;..\CONFIG\MPU6050\eMPL
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c system_stm32f4xx.c include.h
  group Analysis
    ../SRC/PID/: pid.c
    ../SRC/FSM/: fsm.c
    ../SRC/SPEED_ANALYSIS/: speed_analysis.c
    ../SRC/DEBUG/: datascope.c
  group PERPHERAL
    ../SRC/PERPHERAL/: voice_broadcast.c
  group BSP
    ../CONFIG/BSP/: bsp_motor.c bsp_usart.c bsp_hc_sr04.c bsp_steering.c bsp_microswitch.c bsp_lcd_init.c bsp_lcd.c bsp_uart.c
  group MPU6050
    ../CONFIG/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../CONFIG/MPU6050/: mpu6050.c
    ../CONFIG/IIC/: myiic.c
  group FreeRtos
    ../CONFIG/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../CONFIG/FreeRTOS/portable/MemMang/: heap_4.c
    ../CONFIG/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group CORE
    ../CONFIG/CORE/: startup_stm32f40_41xxx.s
  group SYSTERM
    ../CONFIG/system/delay/: delay.c
    ../CONFIG/system/sys/: sys.c
    ../CONFIG/system/usart/: usart.c
  group FEWLIB
    ../CONFIG/FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_dbgmcu.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
